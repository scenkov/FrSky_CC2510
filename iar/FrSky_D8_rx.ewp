# IAR project FrSky_D8_rx.ewp, settings and files
configuration Debug on CC1110 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC1110.i51
  ICC8051.CCDefines: chip=1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CODE\PER_TEST\INCLUDE; ..\CODE\LIBRARY\HAL\INCLUDE; ..\CODE\LIBRARY\HAL_BUI\INCLUDE
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 1
  A8051.ADefines: chip=1110
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration Build .hex for CC1110 (8051)
  as the first configuration, except:
  ICC8051.CCOptLevel: 3
configuration Debug on CC2510 (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  ICC8051.CCDefines: chip=2510
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration Build .hex for CC2510 (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  ICC8051.CCDefines: chip=2510
  ICC8051.CCOptLevel: 3
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
  group (top)
    ../code/PER_test/source/: flash_asm.s51 per_test_dma.c per_test_main.c per_test_radio.c uart.c
    ../code/Library/HAL/source/: hal_power_clk_mgmt.c
  group hal
    ../code/Library/HAL/source/: hal_adc_mgmt.c hal_wait.c
  group hal_bui
    ../code/Library/HAL_BUI/source/: hal_bui_button.c hal_bui_joystick.c hal_bui_lcd.c
